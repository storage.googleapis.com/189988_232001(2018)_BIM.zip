Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-08-23T10:48:32
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 23 10:48:32 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{A73ADEB4-2823-4EC3-BF50-504620B812AA}\ifc * Database version: 5507 * Database creation date: Fri Aug 23 10:48:32 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 23 10:48:32 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 23 10:48:32 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 232001 Overhead shower, 232001(2018):232001 Overhead shower:412371
In: Level 1
Type - PredefinedType: FAUCET
Type - Dimensions(Type) - NominalDepth: 95 mm; NominalHeight: 56.13 mm; NominalWidth: 95 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 232001(2018); ConvergoRefNr: 0087-1909-0089-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Shower heads; NBSReference: 45-35-70/333; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_76; Uniclass2015Description: Shower heads; Uniclass2015Reference: Pr_40_20_87_76; Version: 1; VersionDate: 23/07/2019
Type - Green Building Properties(Type) - Customs Code: 84819000; EAN Number: 6414150077609; LVI Number: 6510203; NRF Number: 4205009; RSK Number: 8237321; VVS Number: 736314004
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/232001; Catalog Drawing URL: http://static.oras.com/catdrw/232001; Dimension Drawing URL: http://static.oras.com/dimdrw/232001; FDV Document URL: http://www.oras.com/datasheet/232001/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/232001; Group: Shower accessories; Long Marketing: Overhead shower Oras Apollo. Ball joint G1/2 connections 60° swivel. Water consumption limited to 15 l/min. Shower headsize 95 mm.; Manufacturer: Oras; Market: NOR;POL;EST;LTU;UKR; Model: 232001 Overhead shower; Name_en: 232001 Overhead shower; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 96 x 96 x 58; Package Weight: 0.197 kg; Product Code: 232001; Product Datasheet: http://www.oras.com/datasheet/232001/en; Product Family: Oras Apollo; Product Image URL: http://static.oras.com/image/232001; Product URL: http://static.oras.com/232001; Type Name: 232001 Overhead shower
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Limescale Protection Technology; Connection Size: G1/2; DN Size: DN15; Flow Rate At 300kPa With Flow Controller: 0.00882867 m3/s; Installation and Maintenance: http://static.oras.com/manual/232001; Max. Hot Water Supply: 65 kg/K/s3; Over Head Shower Size: Ø 95 mm; Shower Spray: Intense; Shower Spray Number: 1Spray
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Shower; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 232001(2018); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 232001; Name: 232001 Overhead shower; ReplacementCost: n/a; Shape: Sculptured; Size: 95x95x55 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 232001; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 232001 Overhead shower
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Moves With Nearby Elements: no; Offset: 0 mm
Dimensions - Area: 0.0196897 m2; Volume: 0.000506574 m3
Identity Data - Mark: 2
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 232001(2018): 232001 Overhead shower; Family and Type: 232001(2018): 232001 Overhead shower; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 232001(2018): 232001 Overhead shower; Type Id: 232001(2018): 232001 Overhead shower; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
